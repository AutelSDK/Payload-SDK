# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app
  AfterMake: fromelf.exe --bin -o ..\..\04_tools\app.bin output\app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c misc: --gnu -o0  -g  -W --diag_warning 1546
  c include: ..\projects;..\usb;..\usb\usb_device_lib\device_core;..\usb\usb_dev_cdc;..\usb\usb_device_lib\device_class\single_cdc;..\libraries\cmsis\Include;..\libraries\cmsis\Device\HDSC\hc32f4xx\Include;..\libraries\libs;..\libraries\hc32_ll_driver\inc;..\rtos\FreeRTOS\Source\CMSIS_RTOS;..\rtos\FreeRTOS\Source\include;..\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\bsp;..\task;..\hal;..\app;..\..\..\..\..\..\..\psdk_lib\core_sdk\config;..\..\..\..\..\..\..\psdk_lib\core_sdk\config\linux;..\..\..\..\..\..\..\psdk_lib\core_sdk\config\mcu;..\..\..\..\..\..\..\psdk_lib\include;..\..\..\common\osal;..\rtt\Config;..\rtt\RTT;..\..\..\..\..\..\..\psdk_lib\core_sdk;..\..\..\..\..\..\module_sample
  library: MicroLIB
  memory RVCT4: ROM 0xa000 size 0x3a000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8100 size 0x2ef00
  memory RVCT10: RAM 0x1fff8000 size 0x100
  link misc: --keep=*Handler
  group cmsis
    ../libraries/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ../task/: startup_hc32f460.s
  group source
    ../task/: main.c hc32f4xx_it.c
    ../hal/: hal_uart.c hal_uart.h
  group usb_host
    ../usb/usb_device_lib/device_class/single_cdc/: usb_dev_cdc_class.c
    ../usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
  group usb_cdc
    ../usb/usb_dev_cdc/: cdc_data_process.c usb_bsp.c usb_dev_desc.c usb_dev_user.c
  group bsp
    ../bsp/: bsp_gpio.c bsp_adc.c bsp_tim.c bsp.c bsp_flash.c bsp_debug.c bsp_led.c bsp_uart_dma.c
  group libraries
    ../libraries/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c
  group FreeRtos
    ../rtos/FreeRTOS/Source/: cpu_utils.c croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../rtos/FreeRTOS/Source/include/: FreeRTOSConfig.h
    ../rtos/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group stdlib
    ../libraries/libs/: lib_crc16.c lib_crc32.c lib_fifo.c
  group app
    ../app/: application.c upgApplication.c apply_high_power.c pps.c
  group rtt
    ../rtt/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group common
    ../../../common/osal/: osal.c
  group psdk_lib
    ../../../../../../../psdk_lib/lib/: libpsdk.lib
  group example
    ../../../../../../module_sample/: test_camera_manager.c test_data_transmission.c test_fc_subscription.c test_flight_control.c test_gimbal.c test_gimbal_manager.c test_hms_manager.c test_logger.c test_positioning.c test_power_management.c test_time_sync.c test_upgrade.c test_waypoint.c uav_sdk_app_info.c test_widget_thrower.c test_widget_parachute.c test_widget_lightSpeaker.c test_camera.c
